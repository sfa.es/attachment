Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-08-23T10:15:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 23 10:15:04 2019 * Host: PC-20171010MMUW * Database: C:\Users\ADMINI~1\AppData\Local\Temp\{D7F287CA-866F-4743-BE36-4B939E5D915E}\ifc * Database version: 5507 * Database creation date: Fri Aug 23 10:14:40 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 23 10:14:41 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 23 10:14:41 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: SFA020003, SFA020003:SFA020003:125875
In: Level 1
Material: Material 1
Pset_ManufacturerTypeInformation - Manufacturer: SFA
Pset_DistributionFlowElementCommon - Reference: SFA020003
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.42993 m2; Volume: 0.0170319 m3; Diamètre entrée 1: 40 mm; Diamètre entrée 2: 100 mm; Diamètre entrée 3: 40 mm; Diamètre entrée 4: 40 mm; Diamètre évacuation: 50 mm; Diamètre ventilation: 50 mm
Identity Data - Mark: 1; Manufacturer: SFA; Model: CUBIC 1 NM ip67; Type Name: SFA020003
Other - Category: Plumbing Fixtures; Family: SFA020003: SFA020003; Family and Type: SFA020003: SFA020003; Type: SFA020003: SFA020003; Type Id: SFA020003: SFA020003; Family Name: SFA020003; Polantis code: SFA020003
Phasing - Phase Created: New Construction
Electrical - Loads - Charge apparente: 0 W; Facteur de puissance: 1; Indice de charge: Moteur
Electrical Engineering - Nombre de pôles: 1; Tension d'alimentation: 230 V
Materials and Finishes - Material 1: Material 1
Mechanical - Flux entrée 1: 0 m3/s; Flux entrée 2: 0 m3/s; Flux entrée 3: 0 m3/s; Flux entrée 4: 0 m3/s; Flux évacuation: 0 m3/s; Perte de charge entrée 1: 0 Pa; Perte de charge entrée 2: 0 Pa; Perte de charge entrée 3: 0 Pa; Perte de charge entrée 4: 0 Pa; Perte de charge évacuation: 0 Pa
Mechanical - Flow - Flux ventilation: 0 m3/s; Perte de charge ventilation: 0 Pa
