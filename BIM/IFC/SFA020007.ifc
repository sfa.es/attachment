Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-08-22T10:39:49
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140223_1515(x64) - Exporter 2015.0.2014.0223 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Aug 22 10:39:49 2019 * Host: PC-20170117ZWHS * Database: C:\Users\ADMINI~1\AppData\Local\Temp\{88C3A13A-CAF9-49C9-9878-C1496E20160B}\ifc * Database version: 5507 * Database creation date: Thu Aug 22 10:39:44 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Aug 22 10:39:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Aug 22 10:39:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: SFA020007, SFA020007:SFA020007:125883
In: Level 1
Material: Material 1, Material 3, Material 2
Pset_ManufacturerTypeInformation - Manufacturer: SFA
Pset_DistributionFlowElementCommon - Reference: SFA020007
Constraints - Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 3.72957 m2; Volume: 0.0568458 m3; Diamètre entrée 1: 40 mm; Diamètre entrée 2: 100 mm; Diamètre entrée 3: 40 mm; Diamètre entrée 4: 40 mm; Diamètre entrée 5: 40 mm; Diamètre évacuation: 100 mm; Diamètre ventilation: 70 mm
Identity Data - Mark: 1; Manufacturer: SFA; Model: SANICUBIC 2 VX; Type Name: SFA020007
Mechanical - System Classification: Other Air,Power,Sanitary; Flux entrée 1: 0 m3/s; Flux entrée 2: 0 m3/s; Flux entrée 3: 0 m3/s; Flux entrée 4: 0 m3/s; Flux entrée 5: 0 m3/s; Flux évacuation: 0 m3/s; Perte de charge entrée 1: 0 Pa; Perte de charge entrée 2: 0 Pa; Perte de charge entrée 3: 0 Pa; Perte de charge entrée 4: 0 Pa; Perte de charge entrée 5: 0 Pa; Perte de charge évacuation: 0 Pa
Other - Category: Plumbing Fixtures; Family: SFA020007: SFA020007; Family and Type: SFA020007: SFA020007; Type: SFA020007: SFA020007; Type Id: SFA020007: SFA020007; Family Name: SFA020007; Polantis code: SFA020007
Phasing - Phase Created: New Construction
Electrical - Loads - Charge apparente: 0 W; Facteur de puissance: 1; Indice de charge: Moteur
Electrical Engineering - Nombre de pôles: 1; Tension d'alimentation: 230 V
Materials and Finishes - Material 1: Material 1; Material 2: Material 2; Material 3: Material 3; Material 4: Material 4
Mechanical - Flow - Flux ventilation: 0 m3/s; Perte de charge ventilation: 0 Pa
