Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-08-23T10:26:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 23 10:26:20 2019 * Host: SKY-20180930RSJ * Database: C:\Users\ADMINI~1.SKY\AppData\Local\Temp\{AFCEEE7C-90F9-4C89-AEE5-9153885F1E1B}\ifc * Database version: 5507 * Database creation date: Fri Aug 23 10:26:18 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 23 10:26:18 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 23 10:26:18 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: SFA020001, SFA020001:SFA020001:124927
In: Level 1
Material: Material 1, Material 2
Pset_ManufacturerTypeInformation - Manufacturer: SFA
Pset_DistributionFlowElementCommon - Reference: SFA020001
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 3.74224 m2; Volume: 0.615755 m3; Diamètre dérivation de pression: 100 mm; Diamètre entrée: 150 mm; Diamètre pompe à membrane manuelle: 40 mm; Diamètre ventilation: 100 mm
Identity Data - Mark: 1; Manufacturer: SFA; Model: SANICUBIC 1 SC; Type Name: SFA020001
Other - Category: Plumbing Fixtures; Family: SFA020001: SFA020001; Family and Type: SFA020001: SFA020001; Type: SFA020001: SFA020001; Type Id: SFA020001: SFA020001; Family Name: SFA020001; Polantis code: SFA020001
Phasing - Phase Created: New Construction
Electrical - Loads - Charge apparente: 0 W; Facteur de puissance: 1; Indice de charge: Moteur
Electrical Engineering - Nombre de pôles: 1; Tension d'alimentation: 230 V
Materials and Finishes - Material 1: Material 1; Material 2: Material 2
Mechanical - Flux dérivation de pression: 0 m3/s; Flux entrée: 0 m3/s; Flux pompe à membrane manuelle: 0 m3/s; Perte de charge dérivation de pression: 0 Pa; Perte de charge entrée: 0 Pa; Perte de charge pompe à membrane manuelle: 0 Pa
Mechanical - Flow - Flux ventilation: 0 m3/s; Perte de charge ventilation: 0 Pa
